# Keil uVision project Blinky.uvprojx, settings and files
target STM32F756 RAM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: VECT_TAB_SRAM USE_IOEXPANDER
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  group Source Files
    ./: test_CAN1.c
  group Documentation
    ./: Abstract.txt
target STM32F756 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_IOEXPANDER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:LED 1.1.1, CMSIS Driver:CAN 1.6.0, Device:STM32Cube Framework:Classic 1.2.0, Device:STM32Cube HAL:ADC 1.2.0, Device:STM32Cube HAL:CAN 1.2.0, Device:STM32Cube HAL:Common 1.2.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:DMA 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:I2C 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:Startup 1.2.0
